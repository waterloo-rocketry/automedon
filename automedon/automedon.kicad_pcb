File: automedon/automedon.kicad_pcb (KiCad board)
At the start: 2 copper layers, 0 parts

Commit message: Schematic ~70% done
Other:
- board text added: "RLCS Towerside"
